# Keil uVision project LCD.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODP2
  output: T-Rex_LCD +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../../../../pratica4-20260517T191259Z-3-001/pratica4/Objects/: tRex_LCD.c
